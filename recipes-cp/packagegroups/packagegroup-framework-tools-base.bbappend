RDEPENDS_packagegroup-framework-tools-base-core_remove = "usbotg-gadget-config"