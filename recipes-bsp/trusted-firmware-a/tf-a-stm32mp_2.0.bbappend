FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-dts-add-stm32mp1-cp-dts-support.patch"

