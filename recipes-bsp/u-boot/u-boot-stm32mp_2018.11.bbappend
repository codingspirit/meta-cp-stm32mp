FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cp-board-add-dts-support-for-cp-board.patch"

